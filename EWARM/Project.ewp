# IAR project Project.ewp, settings and files
configuration MARM-DDS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\lib\CMSIS\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\utils\STM32F4-Discovery; ..\utils\lwip_v1.3.2\src\include\netif; ..\utils\lwip_v1.3.2\src\include\lwip; ..\utils\lwip_v1.3.2\src\include\ipv4; ..\utils\lwip_v1.3.2\src\include; ..\utils\lwip_v1.3.2\port\STM32F4x7\Standalone; ..\utils\lwip_v1.3.2\port\STM32F4x7; ..\lib\STM32F4x7_ETH_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group LWIP
    ../utils/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../utils/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../utils/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../utils/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../utils/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group Readme
    ../: readme.txt
  group STM32F4-Discovery
    ../utils/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c
  group STM32F4x7_ETH_Driver
    ../lib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group User
    ../src/: main.c netconf.c stm32f4x7_eth_bsp.c stm32f4xx_it.c system_stm32f4xx.c dds.c dds_server.c
